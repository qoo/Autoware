Commit message: support pashr

File: ros/src/.config/model/drone.urdf (robot description, URDF)
Before this commit: robot car, 1 links, 0 joints
Links:
- link base_link: geometry visual mesh filename=package://model_publisher/../../../.config/model/Drone_dae.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 scale=20.0 20.0 20.0
